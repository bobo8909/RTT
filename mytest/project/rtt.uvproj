# Keil uVision project rtt.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtt +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\apps;..\drivers;..\..\RT-Thread\include;..\..\RT-Thread\components\finsh;..\third_part\STM32F10x_StdPeriph_Driver\inc;..\..\RT-Thread\libcpu\arm\common;..\..\RT-Thread\libcpu\arm\cortex-m3;..\third_part\CMSIS\CM3\CoreSupport;..\third_part\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\RT-Thread\components\dfs\include;..\..\RT-Thread\components\dfs\filesystems\romfs;..\..\RT-Thread\components\dfs\filesystems\elmfat;..\..\RT-Thread\components\drivers\include;..\..\RT-Thread\components\init;..\..\RT-Thread\components\drivers;..\..\RT-Thread\components\drivers\include\drivers;..\..\RT-Thread\components\net\lwip\src\include;..\..\RT-Thread\components\net\lwip\src\arch\include;..\..\RT-Thread\components\net\lwip\src;..\..\RT-Thread\components\net\lwip\src\include\ipv4;..\..\RT-Thread\components\net\lwip\src\include\lwip;..\..\RT-Thread\components\dfs\filesystems\nfs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group StartUp
    ../apps/: application.c board.c startup.c stm32f10x_it.c
    ../drivers/: led.c rtc.c serial.c usart.c
  group Apps
    ../apps/: telnet.c tcpclient.c
  group Driver
    ../drivers/: spi_flash_w25qxx.c stm32f10xx_spi.c stm32f1xx_sd.c dm9000a.c
  group cm3
    ../../RT-Thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group STM32_StdPeriph
    ../third_part/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../third_part/CMSIS/CM3/CoreSupport/: core_cm3.c
  group kernel
    ../../RT-Thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Finsh
    ../../RT-Thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group filesystem
    ../../RT-Thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../RT-Thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../RT-Thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../RT-Thread/components/dfs/filesystems/elmfat/option/: ccfile.c
  group device drives
    ../../RT-Thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../RT-Thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c
  group components
    ../../RT-Thread/components/init/: components.c
  group LwIP
    ../../RT-Thread/components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../RT-Thread/components/net/lwip/src/arch/: sys_arch.c
    ../../RT-Thread/components/net/lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../RT-Thread/components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../RT-Thread/components/net/lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group nfs
    ../../RT-Thread/components/dfs/filesystems/nfs/: dfs_nfs.c mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c
    ../../RT-Thread/components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c pmap.c rpc_prot.c xdr.c xdr_mem.c
